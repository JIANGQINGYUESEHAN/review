# Keil uVision project ALL_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Drive;.\Drive\led;.\Drive\Drive_KEY;.\Drive\Drive_USART;.\Drive\Drive_USART_Interrupt;.\Drive\Drive_I2C;.\Inf\E2PROM;.\Inf\E2PROM_HardWare;.\Drive\Drive_I2C_HardWare;.\Drive\Drive_BaseTick;.\Drive\Drive_GeneralTick;.\Drive\Drive_GeneralTickTest;.\Drive\Drive_DMATOUATR;.\Drive\Drive_DMA;.\Drive\Drive_MesureTick;.\Drive\Drive_SenierTick;.\Drive\Drive_ADC;.\Drive\Drive_ADC_DMA;.\Drive\Drive_SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c Delay.c Delay.h
  group Drive_LED
    ./Drive/led/: led.c led.h
  group Drive_KEY
    ./Drive/Drive_KEY/: Drive_KEY.h Drive_KEY.c
  group Drive_USART
    ./Drive/Drive_USART/: Drive_USART.h Drive_USART.c
  group Drive_USART_INTERRUPT
    ./Drive/Drive_USART_Interrupt/: Drive_USART_Interrupt.c Drive_USART_Interrupt.h
  group Drive_I2C
    ./Drive/Drive_I2C/: Drive_I2C.c Drive_I2C.h
  group In_E2PROM
    ./Inf/E2PROM/: Inf_E2PROM.c Inf_E2PROM.h
  group E2PROM_HardWare
    ./Inf/E2PROM_HardWare/: Inf_E2PROM_HardWare.c Inf_E2PROM_HardWare.h
  group I2C_HardWare
    ./Drive/Drive_I2C_HardWare/: Drive_I2C_HardWare.c Drive_I2C_HardWare.h
  group Base_Tick
    ./Drive/Drive_BaseTick/: Drive_BaseTick.c Drive_BaseTick.h
  group Mesure_Tick
    ./Drive/Drive_MesureTick/: Drive_MesureTick.c Drive_MesureTick.h
  group General_Tick
    ./Drive/Drive_GeneralTick/: Drive_GeneralTick.c Drive_GeneralTick.h
  group SenierTick
    ./Drive/Drive_SenierTick/: Drive_SenierTick.c Drive_SenierTick.h
  group Drive_DMA
    ./Drive/Drive_DMA/: Drive_DMA.c Drive_DMA.h
  group Drive_DMATOUATR
    ./Drive/Drive_DMATOUATR/: Drive_DMATOUATR.c Drive_DMATOUATR.h
  group Drive_ADC
    ./Drive/Drive_ADC/: Drive_ADC.c Drive_ADC.h
  group Drive_ADC_DMA
    ./Drive/Drive_ADC_DMA/: Drive_ADC_DMA.c Drive_ADC_DMA.h
  group Drive_SPI
    ./Drive/Drive_SPI/: Drive_SPI.c Drive_SPI.h
